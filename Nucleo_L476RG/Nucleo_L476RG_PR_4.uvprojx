# Keil uVision project Nucleo_L476RG_PR_4.uvprojx, settings and files
target Target_Interrupts (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_L476RG_button_interrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\AppData\Local\Arm\Packs\Keil\STM32L4xx_DFP\2.2.0\Drivers\STM32L4xx_HAL_Driver\Inc\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group SourceGroup
    ./: main.c Thread.c
    ../../../AppData/Local/Arm/Packs/Keil/STM32L4xx_DFP/2.2.0/Drivers/CMSIS/Device/ST/STM32L4xx/Include/: stm32l476xx.h
    ../../../AppData/Local/Arm/Packs/Keil/STM32L4xx_DFP/2.2.0/Drivers/STM32L4xx_HAL_Driver/Inc/: stm32l4xx_hal.h stm32l4xx_hal_gpio.h stm32l4xx_hal_tim.h
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.3.1
